Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-11T15:21:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 11 15:21:12 2018 * Host: B3ROBRAWR4425 * Database: C:\Users\DDA\AppData\Local\Temp\{C7195BF5-A1B0-4578-ACF3-589467A9DE95}\ifc * Database version: 5507 * Database creation date: Mon Jun 11 15:21:10 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Jun 11 15:21:10 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 11 15:21:10 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: AL1230SB, E_Power Supply_MEPcontent_TIL Technologies_AL1230SB_FR-EN:AL1230SB:1289856
In: V00
Type - Material: Color RGB 240-240-240, RAL 7016, Color RGB 000-136-206, RAL 3031, RAL 9005, Color RGB 022-063-031
Type - Dimensions - Depth: 60 mm; Height: 110 mm; Width: 85 mm
Type - Electrical - Humidity Range: 20 to 95%; Input Voltage: 190 to 264 V; Operating Temperature: -20°C to +60°C; Output Voltage: 13.6 VDC
Type - Identity Data - Article Description: 220V-12V - 4A Power supply charger; Article Type: AL1230SB; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: 220V-12V - 4A Power supply charger; EMCS Version: 3.0; ETIM Article Class: EC000675; Family Version: 11.15; Manufacturer: TIL Technologies; Manufacturer Art. No.: AL1230SB; Manufacturer URL: http://www.til-technologies.com; MEPcontent Class: POWER_SUPPLY_CHARGER; Model: AL1230SB; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; Product Line: NG series; Revit Version: 2017; Type Name: AL1230SB; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Other - Category: Security Devices; Family Name: E_Power Supply_MEPcontent_TIL Technologies_AL1230SB_FR-EN
Pset_BuildingElementProxyCommon - Reference: AL1230SB; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: TIL Technologies
Constraints - Offset: 0 mm
Dimensions - Area: 0.0236981 m2; Volume: 0.000565146 m3
Identity Data - Mark: 1
Other - Family: E_Power Supply_MEPcontent_TIL Technologies_AL1230SB_FR-EN: AL1230SB; Family and Type: E_Power Supply_MEPcontent_TIL Technologies_AL1230SB_FR-EN: AL1230SB; Type: E_Power Supply_MEPcontent_TIL Technologies_AL1230SB_FR-EN: AL1230SB; Type Id: E_Power Supply_MEPcontent_TIL Technologies_AL1230SB_FR-EN: AL1230SB
Phasing - Phase Created: 4. Plan over 10 years
